# Keil uVision project Main_Control-V6.0.uvprojx, settings and files
target Main_Control-V6.0 (6160000::V6.16::ARMCLANG)
  device: STM32H725IGKx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2404FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: Main_Control-V6.0 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H725xx
  c include: ../Core/Inc;../FATFS/Target;../FATFS/App;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FatFs/src;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Core/SDRAM;../Core/FLASH;../Core/LCD;../Core/lvgl;../Core/lvgl/myself;../Core/lvgl/porting;../Core/lvgl/symbol
  memory RVCT1: ROM 0x90000000 size 0x2000000
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0xc0000000 size 0x2000000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32h725xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c fmc.c i2c.c octospi.c sdmmc.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: bsp_driver_sd.c sd_diskio.c fatfs_platform.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_ll_fmc.c stm32h7xx_hal_sdram.c stm32h7xx_hal_ospi.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c cc936.c
  group SDRAM
    ../Core/SDRAM/: sdram.c
  group FLASH
    ../Core/FLASH/: Flash.c
  group LCD
    ../Core/LCD/: ST7789V.c GT911.c
  group LVGL_SRC
    ../Core/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../Core/lvgl/src/draw/arm2d/: lv_gpu_arm2d.c
    ../Core/lvgl/src/draw/gd32_ipa/: lv_gpu_gd32_ipa.c
    ../Core/lvgl/src/draw/nxp/pxp/: lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ../Core/lvgl/src/draw/nxp/vglite/: lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_rect.c lv_gpu_nxp_vglite.c
    ../Core/lvgl/src/draw/nxp/: lv_gpu_nxp.c
    ../Core/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../Core/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../Core/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../Core/lvgl/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ../Core/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_cache_builtin.c lv_img_decoder.c
    ../Core/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../Core/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../Core/lvgl/src/layouts/flex/: lv_flex.c
    ../Core/lvgl/src/layouts/grid/: lv_grid.c
    ../Core/lvgl/src/libs/barcode/: code128.c lv_barcode.c
    ../Core/lvgl/src/libs/bmp/: lv_bmp.c
    ../Core/lvgl/src/libs/ffmpeg/: lv_ffmpeg.c
    ../Core/lvgl/src/libs/freetype/: lv_freetype.c lv_ftsystem.c
    ../Core/lvgl/src/libs/fsdrv/: lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../Core/lvgl/src/libs/gif/: gifdec.c lv_gif.c
    ../Core/lvgl/src/libs/png/: lodepng.c lv_png.c
    ../Core/lvgl/src/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../Core/lvgl/src/libs/rlottie/: lv_rlottie.c
    ../Core/lvgl/src/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../Core/lvgl/src/libs/tiny_ttf/: lv_tiny_ttf.c
    ../Core/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_malloc_builtin.c lv_math.c lv_mem.c lv_memcpy_builtin.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../Core/lvgl/src/others/file_explorer/: lv_file_explorer.c
    ../Core/lvgl/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../Core/lvgl/src/others/gridnav/: lv_gridnav.c
    ../Core/lvgl/src/others/ime/: lv_ime_pinyin.c
    ../Core/lvgl/src/others/imgfont/: lv_imgfont.c
    ../Core/lvgl/src/others/monkey/: lv_monkey.c
    ../Core/lvgl/src/others/msg/: lv_msg.c
    ../Core/lvgl/src/others/snapshot/: lv_snapshot.c
    ../Core/lvgl/src/themes/basic/: lv_theme_basic.c
    ../Core/lvgl/src/themes/default/: lv_theme_default.c
    ../Core/lvgl/src/themes/mono/: lv_theme_mono.c
    ../Core/lvgl/src/widgets/animimg/: lv_animimg.c
    ../Core/lvgl/src/widgets/arc/: lv_arc.c
    ../Core/lvgl/src/widgets/bar/: lv_bar.c
    ../Core/lvgl/src/widgets/btn/: lv_btn.c
    ../Core/lvgl/src/widgets/btnmatrix/: lv_btnmatrix.c
    ../Core/lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Core/lvgl/src/widgets/canvas/: lv_canvas.c
    ../Core/lvgl/src/widgets/chart/: lv_chart.c
    ../Core/lvgl/src/widgets/checkbox/: lv_checkbox.c
    ../Core/lvgl/src/widgets/colorwheel/: lv_colorwheel.c
    ../Core/lvgl/src/widgets/dropdown/: lv_dropdown.c
    ../Core/lvgl/src/widgets/img/: lv_img.c
    ../Core/lvgl/src/widgets/imgbtn/: lv_imgbtn.c
    ../Core/lvgl/src/widgets/keyboard/: lv_keyboard.c
    ../Core/lvgl/src/widgets/label/: lv_label.c
    ../Core/lvgl/src/widgets/led/: lv_led.c
    ../Core/lvgl/src/widgets/line/: lv_line.c
    ../Core/lvgl/src/widgets/list/: lv_list.c
    ../Core/lvgl/src/widgets/menu/: lv_menu.c
    ../Core/lvgl/src/widgets/meter/: lv_meter.c
    ../Core/lvgl/src/widgets/msgbox/: lv_msgbox.c
    ../Core/lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    ../Core/lvgl/src/widgets/roller/: lv_roller.c
    ../Core/lvgl/src/widgets/slider/: lv_slider.c
    ../Core/lvgl/src/widgets/span/: lv_span.c
    ../Core/lvgl/src/widgets/spinbox/: lv_spinbox.c
    ../Core/lvgl/src/widgets/spinner/: lv_spinner.c
    ../Core/lvgl/src/widgets/switch/: lv_switch.c
    ../Core/lvgl/src/widgets/table/: lv_table.c
    ../Core/lvgl/src/widgets/tabview/: lv_tabview.c
    ../Core/lvgl/src/widgets/textarea/: lv_textarea.c
    ../Core/lvgl/src/widgets/tileview/: lv_tileview.c
    ../Core/lvgl/src/widgets/win/: lv_win.c
  group LVGL_POR
    ../Core/lvgl/porting/: lv_port_disp.c lv_port_indev.c
  group LVGL_APP
    ../Core/lvgl/myself/: lv_app.c lv_app_function.c
  group LVGL_FONT
    ../Core/lvgl/font/: DingTalk_JinBuTi_Chinese_16.c DingTalk_JinBuTi_English_14.c
  group LVGL_SYMBOL
    ../Core/lvgl/symbol/: My_Symbol_15.c
software components: CMSIS:CORE 5.5.0
